# Keil uVision project NEWBUY_KitBoard.uvproj, settings and files
target NEWBUY_KitBoard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NEWBUY_KitBoard +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\CMSIS;.\Source;.\Source\FATFS;.\Source\LCDDriver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group srartup
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./Source/: main.c sdcard.c stm32f10x_it.c systick.c usart_printf.c spi.c
  group LCDDriver
    ./Source/LCDDriver/: LCD.c Touch.c
  group FATFS
    ./Source/FATFS/: diskio.c ff.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_spi.c
